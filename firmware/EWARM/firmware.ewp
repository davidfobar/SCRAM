# IAR project firmware.ewp, settings and files
configuration firmware (ARM, debug)
  General.OGChipSelectEditMenu: STM32WLE5JC ST STM32WLE5JC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WLE5xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: firmware.hex
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkIcfFile: stm32wle5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
